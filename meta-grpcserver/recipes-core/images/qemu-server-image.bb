require recipes-core/images/core-image-minimal.bb


IMAGE_INSTALL += "grpcserver"
DISTRO_FEATURES += "wifi"
